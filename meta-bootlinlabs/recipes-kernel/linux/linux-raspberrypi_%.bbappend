FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://uncompressed_modules.cfg"
